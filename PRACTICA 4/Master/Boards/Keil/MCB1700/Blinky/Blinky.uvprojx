# Keil uVision project Blinky.uvprojx, settings and files
target LPC1768 Flash (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Files
    ./: Master.c LED_LPC1768.c LED_LPC1768.h
  group Documentation
    ./: Abstract.txt
target LPC1768 RAM (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x4000
  memory RVCT9: RAM 0x10004000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
software components: CMSIS Driver:I2C:Custom 2.3.0, CMSIS:CORE 5.2.0, CMSIS:RTOS:Keil RTX 4.81.1, CMSIS Driver:I2C 2.6.0, Device:GPIO 1.1.0, Device:PIN 1.0.0, Device:Startup 1.0.0
